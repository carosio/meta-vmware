RECOMMENDS_packagegroup-core-tools-profile_append_vmware = " systemtap"
